options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: multi_tx
    output_language: python
  states: {}

blocks:
- name: am_on
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 4,2,1,1
    label: AM
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '441000000'
  states: {}
- name: cw_on
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 4,5,1,1
    label: CW
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '25'
  states: {}
- name: i_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,7
    label: DC offsett I
    start: '-0.1'
    step: ((0.1) - (-0.1))/200
    stop: '0.1'
    value: '0'
  states: {}
- name: lsb_on
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 4, 3, 1, 1
    label: LSB
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: magnitude
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 7
    label: Magnitude correction
    start: '-0.1'
    step: 0.2/200
    stop: '0.1'
    value: '0'
  states: {}
- name: nbfm_on
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 4,0,1,1
    label: NBFM
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: phase
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1, 7
    label: Phase Correction
    start: '-0.1'
    step: (0.2)/200
    stop: '0.1'
    value: '0'
  states: {}
- name: psk_on
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 4,6,1,1
    label: PSK31
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: q_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,7
    label: DC offsett Q
    start: '-0.1'
    step: ((0.1) - (-0.1))/200
    stop: '0.1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: audio_rate * 40
  states: {}
- name: usb_on
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 4,4,1,1
    label: USB
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: wbfm_on
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 4,1,1,1
    label: WBFM
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: wpm
  id: variable
  parameters:
    value: '15'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: audio_rate * 2
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: 1.0 / 7 if nbfm_on else 0
    freq: '-100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: 1.0 / 7 if wbfm_on else 0
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: 1 if am_on else 0
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_3
  id: analog_sig_source_x
  parameters:
    amp: 1.8 if usb_on else 0
    freq: '14000'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_3_0
  id: analog_sig_source_x
  parameters:
    amp: 1.8 if lsb_on else 0
    freq: '11000'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_4
  id: analog_sig_source_x
  parameters:
    amp: 1.0 / 7
    freq: '120000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_5
  id: analog_sig_source_x
  parameters:
    amp: 1 if cw_on else 0
    freq: '20000'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_6
  id: analog_sig_source_x
  parameters:
    amp: 1 if psk_on else 0
    freq: '22000'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: audio_rate * 4
    tau: '75e-6'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: '2800'
    interp: '1'
    low_cutoff_freq: '200'
    samp_rate: audio_rate
    type: interp_fir_filter_ccc
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: '-200'
    interp: '1'
    low_cutoff_freq: '-2800'
    samp_rate: audio_rate
    type: interp_fir_filter_ccc
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: i_offset + 1j * q_offset
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_3
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_3_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_4
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_5
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_6
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(1.2 * audio_rate / wpm)
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (1,0,1,0,1,0,1,1,1, 0,0,0, 1,0,1,0,1,0,1,1,1, 0,0,0, 1,0,1,0,1,0,1,1,1, 0,0,0,0,0,0,0, 1,1,1,0,1,0,1, 0,0,0, 1, 0,0,0,0,0,0,0, 1,0,1,0,1,0,1,1,1, 0,0,0, 1, 0,0,0, 1,0,1,0,1,0,1,1,1,0,1,1,1, 0,0,0, 1,0,1, 0,0,0, 1,0,1,1,1,0,1, 0,0,0, 1,0,1,1,1,0,1, 0,0,0,0,0,0,0, 1,1,1, 0,0,0, 1, 0,0,0, 1,0,1,0,1, 0,0,0, 1,1,1, 0,0,0, 1,0,1, 0,0,0, 1,1,1,0,1, 0,0,0, 1,1,1,0,1,1,1,0,1, 0,0,0,0,0,0,0)
  states: {}
- name: blocks_vector_source_x_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0,0, 1,1,0,1,1,0,1, 0,0, 1,0,1,0,1,1, 0,0, 1,1,0,1, 0,0, 1,0,1,1,1, 0,0, 1, 0,0, 1,1,0,1, 0,0, 1,0,1,1,1, 0,0, 1, 0,0, 1,1,0,1,1,0,1,0,1, 0,0, 1,1,1,0,1,1,1, 0,0, 1,1,1,1,1,1,1,1, 0,0, 1,1,1,1,1,1,1, 0,0, 1,0,1,0,1,1,1,1, 0,0, 1,0,1,0,1,1,1,1, 0,0, 1, 0,0, 1,0,1, 0,0, 1,1, 0,0, 1,0,1,1,1, 0,0, 1,0,1, 0,0, 1,1,0,1, 0,0, 1,1,1,1, 0,0, 1,0,1,1,0,1,1, 0,0, 1,0,1,0,1,1,1, 0,0, 1,1,1,0,1)
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/warnes/inoui/gnuradio/Audio_Files/multi_tx.wav
    repeat: 'True'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[1,0]'
  states: {}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: '2'
    differential: 'True'
    excess_bw: '0.35'
    mod_code: '"none"'
    samples_per_symbol: '8'
  states: {}
- name: iqbalance_fix_cc_0
  id: iqbalance_fix_cc
  parameters:
    mag: magnitude
    phase: phase
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    gain: '0.5'
    interp: '1'
    samp_rate: audio_rate
    type: interp_fir_filter_ccf
    width: '400'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: AM
  states: {}
- name: note_1
  id: note
  parameters:
    note: Upper sideband
  states: {}
- name: note_2
  id: note
  parameters:
    note: Lower sideband
  states: {}
- name: note_3
  id: note
  parameters:
    note: Wideband FM
  states: {}
- name: note_4
  id: note
  parameters:
    note: Narrowband FM
  states: {}
- name: note_5
  id: note
  parameters:
    note: PSK31
  states: {}
- name: note_6
  id: note
  parameters:
    note: CW
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: center_freq
    gain0: gain
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    name: FFT Plot
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Scope Plot
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samp_rate / audio_rate / 4)
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samp_rate / audio_rate / 2)
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: samp_rate
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_3
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '192'
    taps: ''
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '200'
    samp_rate: audio_rate
    sym_rate: '5'
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_1
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '200'
    samp_rate: audio_rate
    sym_rate: '5'
    type: fir_filter_ccf
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [analog_sig_source_x_2, '0', blocks_multiply_xx_2, '1']
- [analog_sig_source_x_3, '0', blocks_multiply_xx_3, '1']
- [analog_sig_source_x_3_0, '0', blocks_multiply_xx_3_0, '1']
- [analog_sig_source_x_4, '0', blocks_multiply_xx_4, '1']
- [analog_sig_source_x_5, '0', blocks_multiply_xx_5, '1']
- [analog_sig_source_x_6, '0', blocks_multiply_xx_6, '1']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_3, '0']
- [band_pass_filter_0_0, '0', blocks_multiply_xx_3_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_2, '0']
- [blocks_add_const_vxx_1, '0', osmosdr_sink_0, '0']
- [blocks_add_xx_0, '0', iqbalance_fix_cc_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_add_xx_1, '0', rational_resampler_xxx_2, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0_0, '0']
- [blocks_float_to_complex_0, '0', low_pass_filter_1, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_2, '0', blocks_add_xx_1, '0']
- [blocks_multiply_xx_3, '0', blocks_add_xx_1, '2']
- [blocks_multiply_xx_3_0, '0', blocks_add_xx_1, '1']
- [blocks_multiply_xx_4, '0', blocks_add_xx_0, '2']
- [blocks_multiply_xx_5, '0', blocks_add_xx_1, '3']
- [blocks_multiply_xx_6, '0', blocks_add_xx_1, '4']
- [blocks_repeat_0, '0', root_raised_cosine_filter_1, '0']
- [blocks_unpacked_to_packed_xx_0, '0', digital_psk_mod_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [blocks_vector_source_x_2, '0', digital_map_bb_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [digital_map_bb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_psk_mod_0, '0', rational_resampler_xxx_3, '0']
- [iqbalance_fix_cc_0, '0', blocks_add_const_vxx_1, '0']
- [low_pass_filter_1, '0', blocks_add_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_1, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_2, '0', blocks_multiply_xx_4, '0']
- [rational_resampler_xxx_3, '0', blocks_multiply_xx_6, '0']
- [root_raised_cosine_filter_0, '0', blocks_multiply_xx_5, '0']
- [root_raised_cosine_filter_1, '0', root_raised_cosine_filter_0, '0']

metadata:
  file_format: 1
