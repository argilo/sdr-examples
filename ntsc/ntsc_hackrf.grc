options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: ntsc_hackrf
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 438000000+1250000
  states: {}
- name: digital_gain
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samples_per_line * 60 * .999 * 525 / 2
  states: {}
- name: samples_per_line
  id: variable
  parameters:
    value: '768'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '0.1'
    freq: '4500000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 2475000 + 1725000
    low_cutoff_freq: '-2475000 + 1725000'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '500000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ve3irr-testing.dat
    repeat: 'True'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: digital_gain
    type: float
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '0'
    freq0: center_freq
    gain0: '0'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_1, '0', blocks_add_xx_0, '1']
- [band_pass_filter_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-181-g643e1337
